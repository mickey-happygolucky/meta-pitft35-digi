RDEPENDS_${PN}_append = " pitft-init-sato"
